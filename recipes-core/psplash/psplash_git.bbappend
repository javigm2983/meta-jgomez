FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " \
	file://0002-psplash-Change-colors-for-the-Meler-logo.patch \	
"
